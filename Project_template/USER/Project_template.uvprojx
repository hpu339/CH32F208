# Keil uVision project Project_template.uvprojx, settings and files
target Target 1 (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: CH32F208WB WCH
  pack: Keil.WCH32F2xx_DFP.1.0.2
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x28000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project_template +hex
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=5 wLevel=3
  c include: ..\Platform\INC;..\USER;..\CORE
  asm include: ..\Platform\INC;..\CORE;..\USER
  memory RVCT4: ROM 0x8000000 size 0x28000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group STARTUP
    ../CORE/: startup_ch32f20x_D8W.s
  group USER
    ./: main.c system_ch32f20x.c ch32f20x_it.c
  group Platform
    ../Platform/SRC/: ch32f20x_gpio.c ch32f20x_rcc.c ch32f20x_misc.c
software components: CMSIS:CORE 5.6.0

# Keil uVision project Project_template.Target_1.uvprojx, settings and files
target Target_1 (ARM-ADS)
  device: CH32F208WB WCH
  pack: Keil.WCH32F2xx_DFP.1.0.2
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x28000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project_template.axf
  c flags: Optim=2 OneElfS=1 v6Lang=3 wLevel=3
  c misc: -xc -Wno-packed -Wno-missing-variable-declarations -Wno-missing-prototypes -Wno-missing-noreturn -Wno-nonportable-include-path -Wno-reserved-id-macro -Wno-unused-macros -Wno-documentation-unknown-command -Wno-documentation -Wno-license-management -Wno-parentheses-equality -Wno-reserved-identifier
  c include: ..\CH32F208LIB\INC;;../USER;../CORE;../CH32F208LIB/INC
  asm misc: -Wa,armasm,--diag_suppress=A1950W
  asm include: ../Platform/INC;../USER;../CORE;../CH32F208LIB/INC
  memory RVCT4: RAM 0x8000000 size 0x28000
  memory RVCT9: ROM 0x20000000 size 0x8000
  scatter file: ./Project_template.Target 1.sct
  link misc: --summary_stderr --info summarysizes --load_addr_map_info --entry=Reset_Handler
  group STARTUP
    ../CORE/: startup_ch32f20x_D8W.s
  group USER
    ./: main.c system_ch32f20x.c ch32f20x_it.c
  group CH32F208LIB_SRC
    ../CH32F208LIB/SRC/: ch32f20x_gpio.c ch32f20x_misc.c ch32f20x_rcc.c
  group CH32F208LIB_INC
    ../CH32F208LIB/INC/: ch32f20x.h ch32f20x_gpio.h ch32f20x_misc.h ch32f20x_rcc.h
software components: CMSIS:CORE 5.6.0

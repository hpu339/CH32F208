# Keil uVision project Project_template.uvprojx, settings and files
target Project_template (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: CH32F208WB WCH
  pack: Keil.WCH32F2xx_DFP.1.0.2
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x28000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project_template +hex
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=5 wLevel=3
  c misc: -gnu
  c include: ..\USER;..\CORE;..\CH32F208LIB\INC;.cmsis\include;..\HARDWARE
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x28000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group USER
    ../USER/: ch32f20x_it.c main.c system_ch32f20x.c
  group STARTUP
    ../CORE/: startup_ch32f20x_D8W.s
  group HARDWARE
    ../HARDWARE/: HAL_GPIO.c
  group CH32F208LIB_SRC
    ../CH32F208LIB/SRC/: ch32f20x_gpio.c ch32f20x_misc.c ch32f20x_rcc.c ch32f20x_tim.c ch32f20x_usart.c debug.c
  group CH32F208LIB_INC
    ../CH32F208LIB/INC/: ch32f20x_gpio.h ch32f20x_misc.h ch32f20x_rcc.h ch32f20x_tim.h ch32f20x_usart.h ch32f20x.h debug.h
